# Keil uVision project ROBOTICARM.uvprojx, settings and files
target MPU6050 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\USMART;..\HARDWARE\TRANSFER;..\HARDWARE\SERVO4;..\HARDWARE\SERVO1;..\HARDWARE\SERVO2;..\HARDWARE\SERVO3;..\HARDWARE\SERVO5;..\HARDWARE\SERVO6;..\HARDWARE\INFRARED;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\USART3;..\HARDWARE\DAC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c
    ../HARDWARE/TRANSFER/: transfer.c
    ../HARDWARE/SERVO1/: servo1.c
    ../HARDWARE/SERVO4/: servo4.c
    ../HARDWARE/SERVO2/: servo2.c
    ../HARDWARE/SERVO3/: servo3.c
    ../HARDWARE/SERVO5/: servo5.c
    ../HARDWARE/SERVO6/: servo6.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/DAC/: dac.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_dac.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c
  group README
    ../: README.TXT
